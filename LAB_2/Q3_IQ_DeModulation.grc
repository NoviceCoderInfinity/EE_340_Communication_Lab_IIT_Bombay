options:
  parameters:
    author: anupam
    generate_options: qt_gui
    id: Q3_IQ_DeModulation
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /media/anupam/OS/Users/anupa/Desktop/IIT_LECTURES/Year_3/Sem_5/EE_340/LAB_2/dat1.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '40000'
    decim: '1'
    gain: '2.5'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '40000'
    decim: '1'
    gain: '2.5'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '960000'
    interp: '44100'
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_1, '1']
- [blocks_add_xx_0, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_file_source_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_add_xx_0, '0']
- [low_pass_filter_0_0, '0', blocks_add_xx_0, '1']
- [rational_resampler_xxx_0_0_0, '0', audio_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
