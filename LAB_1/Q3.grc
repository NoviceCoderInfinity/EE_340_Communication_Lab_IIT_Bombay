options:
  parameters:
    author: 22b3982_Anupam_Rawat
    generate_options: qt_gui
    id: Q3
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: G1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '5'
  states: {}
- name: G2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '5'
  states: {}
- name: G3
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '5'
  states: {}
- name: G4
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '5'
  states: {}
- name: G5
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '5'
    high_cutoff_freq: '500'
    low_cutoff_freq: '20'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '20'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '5'
    high_cutoff_freq: '14800'
    low_cutoff_freq: '9200'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '400'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '5'
    high_cutoff_freq: '8900'
    low_cutoff_freq: '6100'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '200'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '5'
    high_cutoff_freq: '3000'
    low_cutoff_freq: '550'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_RECTANGULAR
  states: {}
- name: band_pass_filter_0_3
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '5'
    high_cutoff_freq: '6000'
    low_cutoff_freq: '3000'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_RECTANGULAR
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/anupam/Desktop/LAB_1/Bach.wav
    repeat: 'True'
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_add_xx_0, '0']
- [band_pass_filter_0_0, '0', blocks_add_xx_0, '4']
- [band_pass_filter_0_1, '0', blocks_add_xx_0, '3']
- [band_pass_filter_0_2, '0', blocks_add_xx_0, '1']
- [band_pass_filter_0_3, '0', blocks_add_xx_0, '2']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_1, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_2, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
